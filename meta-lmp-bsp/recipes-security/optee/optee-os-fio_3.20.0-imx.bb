require recipes-security/optee/optee-os-fio.inc

SRCREV = "6fc97721edb8d5de24b19f5e29c0ecdc3fc70a90"
SRCBRANCH = "3.20+fio-imx"

DEFAULT_PREFERENCE = "-1"
