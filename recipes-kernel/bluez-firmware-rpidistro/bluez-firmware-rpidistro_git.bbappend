# Known to work revision for Raspberry Pi specific firmware (from meta-raspberrypi)
# Upstream-bug: https://github.com/RPi-Distro/bluez-firmware/issues/4
SRCREV_rpi = "96eefffcccc725425fd83be5e0704a5c32b79e54"
