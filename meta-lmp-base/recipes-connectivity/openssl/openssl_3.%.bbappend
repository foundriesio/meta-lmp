FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"

SRC_URI += "file://0001-translation-EC-legacy-keys-handle-OSSL_PKEY_PARAM_EC.patch"
