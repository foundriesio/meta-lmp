FILES_${PN} += " ${bindir}/weston-screenshooter "
