require u-boot-fio-common.inc

SRCREV = "30cd2b39fb4989dc0e4c69bc5c73b1f169951bf1"
SRCBRANCH = "2024.04+fio"
LIC_FILES_CHKSUM = "file://Licenses/README;md5=2ca5f2c35c8cc335f0a19756634782f1"
