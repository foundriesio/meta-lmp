require optee-examples-fio.inc

SRCREV = "65fc74309e12189ad5b6ce3ffec37c8011088a5a"

SRC_URI += "\
	file://0001-Makefile-Fix-non-portable-sh-check-for-plugins.patch \
"
