SRC_URI:remove = "git://github.com/containerd/containerd;branch=release/2.0;protocol=https;destsuffix=git/src/github.com/containerd/containerd/v2"
SRC_URI:append = "git://github.com/containerd/containerd;branch=release/2.1;protocol=https;destsuffix=git/src/github.com/containerd/containerd/v2"
