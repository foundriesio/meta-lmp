# cpp/cpp-symlinks are not strictly required (more of a suggestion)
RDEPENDS:${PN}:class-target:remove = "cpp cpp-symlinks"
