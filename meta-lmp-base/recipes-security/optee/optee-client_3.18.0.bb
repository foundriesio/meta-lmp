require optee-client-fio.inc

SRCREV = "e7cba71cc6e2ecd02f412c7e9ee104f0a5dffc6f"

SRC_URI += " \
	file://0001-FIO-extras-pkcs11-change-UUID-to-avoid-conflict-with.patch \
"
