# Provided by meta-lmp-base or any other compatible BSP layer
include conf/machine/include/lmp-machine-custom.inc
