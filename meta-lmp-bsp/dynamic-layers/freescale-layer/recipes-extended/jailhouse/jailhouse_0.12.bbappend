# Conflicts with -march=armv8-a+nofp
TUNE_CCARGS:remove:mx93-nxp-bsp = "-mcpu=cortex-a55"
