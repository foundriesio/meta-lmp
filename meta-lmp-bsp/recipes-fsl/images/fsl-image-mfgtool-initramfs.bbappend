# iMX8MM EVK
DEPENDS_remove_imx8mmevk = "u-boot-mfgtool linux-mfgtool"
DEPENDS_append_imx8mmevk = " virtual/bootloader virtual/kernel"
