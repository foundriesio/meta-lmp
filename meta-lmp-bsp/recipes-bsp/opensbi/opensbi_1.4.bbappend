# Export fw_payloads to sysroot
SYSROOT_DIRS += "/share"
