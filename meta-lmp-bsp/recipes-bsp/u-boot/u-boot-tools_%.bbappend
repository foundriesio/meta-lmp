FILESEXTRAPATHS_prepend := "${THISDIR}/u-boot:"

include u-boot-lmp-common.inc
