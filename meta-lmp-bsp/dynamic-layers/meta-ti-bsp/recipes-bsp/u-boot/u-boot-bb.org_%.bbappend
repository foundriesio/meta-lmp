FILESEXTRAPATHS:prepend := "${THISDIR}/u-boot-ti-staging:${THISDIR}/${PN}:"

include u-boot-ti-staging.inc
