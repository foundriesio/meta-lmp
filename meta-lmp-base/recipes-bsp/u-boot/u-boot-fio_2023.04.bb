require u-boot-fio-common.inc

SRCREV = "349b9c93a6f7218d7988caab249f4ad1196f3c30"
SRCBRANCH = "2023.04+fio"
LIC_FILES_CHKSUM = "file://Licenses/README;md5=2ca5f2c35c8cc335f0a19756634782f1"
