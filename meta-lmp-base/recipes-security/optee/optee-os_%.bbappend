# Default OP-TEE OS from meta-arm
PROVIDES = "virtual/optee-os"
