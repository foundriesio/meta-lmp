require optee-examples-fio.inc

SRCREV = "f301ee9df2129c0db683e726c91dc2cefe4cdb65"

SRC_URI += "\
	file://0001-Makefile-Fix-non-portable-sh-check-for-plugins.patch \
"
