require u-boot-fio-common.inc

SRCREV = "6c680cdbe7c115cd43ae0d2e60ac769f581e5586"
SRCBRANCH = "2020.04+imx_5.4.70_2.3.0-fio"
