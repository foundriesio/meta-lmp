FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"

HDF_BASE:vck190-versal = "file://"
HDF_PATH:vck190-versal = "system.xsa"
HDF_EXT:vck190-versal = "xsa"
