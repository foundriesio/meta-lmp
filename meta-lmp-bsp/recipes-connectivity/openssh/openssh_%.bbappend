# BSPs with kernel older than 5.6 (blocking /dev/random reads)
PACKAGECONFIG:apalis-imx8 ?= "rng-tools"
PACKAGECONFIG:tegra ?= "rng-tools"
