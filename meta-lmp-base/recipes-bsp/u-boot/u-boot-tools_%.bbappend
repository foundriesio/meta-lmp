FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

SRC_URI += "file://0001-tools-image-host-fix-wrong-return-value.patch"
