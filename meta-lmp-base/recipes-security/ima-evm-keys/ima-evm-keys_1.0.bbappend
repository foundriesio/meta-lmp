# Set default value to avoid parsing error
IMA_EVM_X509 ?= ""
