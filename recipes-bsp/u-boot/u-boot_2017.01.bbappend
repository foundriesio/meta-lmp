FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

SRC_URI += " \
    file://0001-config-am335x_evm-detect-Black-Wireless-using-BWA.patch \
"
