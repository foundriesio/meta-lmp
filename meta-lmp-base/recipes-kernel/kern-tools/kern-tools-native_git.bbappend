# Needed until oe-core 533720a17 is available in kirkstone
SRCREV = "6a4752ebbe7d242c02b3c74a5772926edd243626"
