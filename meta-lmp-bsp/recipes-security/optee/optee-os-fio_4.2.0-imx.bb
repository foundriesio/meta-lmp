require recipes-security/optee/optee-os-fio.inc

SRCREV = "af115bd85d6e2c204a15c165639e237a00f1b000"
SRCBRANCH = "4.2.0+fio-imx"

DEFAULT_PREFERENCE = "-1"
