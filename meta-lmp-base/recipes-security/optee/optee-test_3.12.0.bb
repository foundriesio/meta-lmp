require optee-test.inc

SRCREV = "7be42398e8848f09995abf8a9e9d8bb8840cc19a"
DEFAULT_PREFERENCE = "-1"
