require optee-os-fio.inc

PV = "3.12.0+git"
SRCREV = "dfcce199d6b9e5acf61d409bb1828d2034b4bae7"
SRCBRANCH = "3.12+fio"

DEFAULT_PREFERENCE = "-1"
