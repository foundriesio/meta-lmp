DEPENDS += "virtual/kernel"
