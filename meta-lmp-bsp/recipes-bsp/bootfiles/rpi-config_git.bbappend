# Disable vc4 overlay via config.txt by default (controlled by the kernel instead)
VC4GRAPHICS = "0"
