RRECOMMENDS:${PN}:remove:imxgpu:mx8mm-nxp-bsp = "libvulkan-imx"
