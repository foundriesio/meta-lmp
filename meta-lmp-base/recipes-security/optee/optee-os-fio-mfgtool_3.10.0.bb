FILESEXTRAPATHS:prepend := "${THISDIR}/optee-os-fio:"

require optee-os-fio_${PV}.bb
