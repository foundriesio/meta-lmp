require optee-os-fio-bsp-mfgtool.inc
