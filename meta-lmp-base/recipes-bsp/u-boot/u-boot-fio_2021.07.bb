require u-boot-fio-common.inc

SRCREV = "068e9ff69182799b1933883d08e25f3f96c9e807"
SRCBRANCH = "2021.07+fio"
LIC_FILES_CHKSUM = "file://Licenses/README;md5=5a7450c57ffe5ae63fd732446b988025"
