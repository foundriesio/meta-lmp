require optee-os-fio_${PV}.bb

DEFAULT_PREFERENCE = "-1"
