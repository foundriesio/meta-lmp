INSANE_SKIP:${PN}-dbg += "buildpaths"
INSANE_SKIP:${PN}-doc += "buildpaths"
