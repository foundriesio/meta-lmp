FILESEXTRAPATHS_prepend := "${THISDIR}/optee-os:"

require optee-os_${PV}.bb
