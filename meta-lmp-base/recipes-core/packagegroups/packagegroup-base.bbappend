# Add aplay/arecord by default.
RDEPENDS:packagegroup-base-alsa += "\
    alsa-utils-aplay \
"
