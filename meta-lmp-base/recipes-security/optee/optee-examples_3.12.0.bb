require optee-examples.inc

SRCREV = "9a755dcf4d8ef6117af59dfd1b1a82315cee58ca"
DEFAULT_PREFERENCE = "-1"
