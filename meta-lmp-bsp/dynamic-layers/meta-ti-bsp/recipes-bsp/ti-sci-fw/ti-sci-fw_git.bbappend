# set a default value for TI_K3_SECDEV_INSTALL_DIR
export TI_K3_SECDEV_INSTALL_DIR = "${STAGING_DIR_NATIVE}${datadir}/ti/ti-k3-secdev"
