require optee-client-fio.inc

SRCREV = "8533e0e6329840ee96cf81b6453f257204227e6c"

SRC_URI += " \
	file://0001-FIO-extras-pkcs11-change-UUID-to-avoid-conflict-with.patch \
"
