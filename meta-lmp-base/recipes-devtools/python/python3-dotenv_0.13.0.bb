HOMEPAGE = "https://github.com/pedroburon/dotenv"
SUMMARY = "Python Dot Env Handler"
DESCRIPTION = "Shell Command and Library to write and read .env like files."
SECTION = "devel/python"
LICENSE = "MIT"
LIC_FILES_CHKSUM = "file://LICENSE;md5=55ee2c3471d386636a719c8ccac40b31"

PYPI_PACKAGE = "python-dotenv"

SRC_URI[md5sum] = "3dfde58c6a5fbd41292c4039a68f70f4"
SRC_URI[sha256sum] = "3b9909bc96b0edc6b01586e1eed05e71174ef4e04c71da5786370cebea53ad74"

inherit pypi setuptools3
