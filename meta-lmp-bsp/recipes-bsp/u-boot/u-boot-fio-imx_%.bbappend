FILESEXTRAPATHS_prepend := "${THISDIR}/u-boot-fio:"
