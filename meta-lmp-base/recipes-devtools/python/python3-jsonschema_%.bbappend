# prefer non gpl runtime dependencies
PACKAGECONFIG = "nongpl"
