# set S to default value
S = "${UNPACKDIR}/${BP}"
