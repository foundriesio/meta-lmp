require optee-examples-fio.inc

SRCREV = "a98d01e1b9168eaed96bcd0bac0df67c44a81081"

SRC_URI += "\
	file://0001-Makefile-Fix-non-portable-sh-check-for-plugins.patch \
"
