require u-boot-fio-common.inc

SRCREV = "2bc91bf4120ff04c53968fcee1d52b70ebf91776"
SRCBRANCH = "2020.10+fio"
LIC_FILES_CHKSUM = "file://Licenses/README;md5=5a7450c57ffe5ae63fd732446b988025"
