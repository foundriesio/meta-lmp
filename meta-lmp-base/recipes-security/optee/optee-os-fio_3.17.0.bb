require optee-os-fio.inc

PV = "3.17.0+git"
SRCREV = "7d80513fbec1c224ee35b3a6aca76d5b94b8ed7c"
SRCBRANCH = "3.17+fio"
