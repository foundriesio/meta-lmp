require u-boot-fio-common.inc

SRCREV = "c621f7a30feb35db1c12ca786c1630c7f603e1f2"
SRCBRANCH = "2023.04+lf-6.1.22-2.0.0-fio"
LIC_FILES_CHKSUM = "file://Licenses/README;md5=2ca5f2c35c8cc335f0a19756634782f1"

DEFAULT_PREFERENCE = "-1"
