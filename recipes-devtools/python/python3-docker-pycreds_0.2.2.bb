SUMMARY = "Python bindings for the docker credentials store API"
HOMEPAGE = "https://github.com/shin-/dockerpy-creds"
LICENSE = "Apache-2.0"
LIC_FILES_CHKSUM = "file://LICENSE;md5=3b83ef96387f14655fc854ddc3c6bd57"

inherit pypi setuptools3

SRC_URI[md5sum] = "ae63c7def3e58cb51a4d8f5810683030"
SRC_URI[sha256sum] = "c7ab85de2894baff6ee8f15160cbbfa2fd3a04e56f0372c5793d24060687b299"
