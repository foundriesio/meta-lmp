FILESEXTRAPATHS:prepend := "${THISDIR}/files:"

SRC_URI:append = " file://Add-missing-cstdint.patch "
