SYSTEMD_AUTO_ENABLE:${PN}-fancontrol:kv260 = "enable"
