# Prefer openssl for TLS instead of gnutls
PACKAGECONFIG = "openssl"
