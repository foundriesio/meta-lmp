require recipes-security/optee/optee-os-fio_${PV}.bb
