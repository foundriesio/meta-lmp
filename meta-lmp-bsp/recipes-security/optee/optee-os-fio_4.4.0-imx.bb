require recipes-security/optee/optee-os-fio.inc

SRCREV = "a475b6048b16c39bad70317674572e1a4bfb1902"
SRCBRANCH = "4.4.0+fio-imx"

DEFAULT_PREFERENCE = "-1"
