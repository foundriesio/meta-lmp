# Disable by default on corstone700 until it is functional
SYSTEMD_AUTO_ENABLE_${PN}_corstone700 = "disable"
