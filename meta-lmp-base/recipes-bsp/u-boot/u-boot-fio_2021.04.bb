require u-boot-fio-common.inc

SRCREV = "a376f0f8012fd026a01a73f2e9b31f060924c20b"
SRCBRANCH = "2021.04+imx_5.10.35-2.0.0-fio"
LIC_FILES_CHKSUM = "file://Licenses/README;md5=5a7450c57ffe5ae63fd732446b988025"
