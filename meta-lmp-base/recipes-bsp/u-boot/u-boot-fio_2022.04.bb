require u-boot-fio-common.inc

SRCREV = "697662376b9fb10a9153bee30569e698ce7a7cde"
SRCBRANCH = "2022.04+fio"
LIC_FILES_CHKSUM = "file://Licenses/README;md5=5a7450c57ffe5ae63fd732446b988025"
