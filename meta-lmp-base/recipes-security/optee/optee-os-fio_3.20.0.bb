require optee-os-fio.inc

SRCREV = "aca0ad78110f9c7aaf01949550f669fc5cb0b34f"
SRCBRANCH = "3.20+fio"
