require optee-os-fio.inc

PV = "3.10.0+git"
SRCREV = "f905edd11382fcabe8a2d48e8e66ab9bf7fc28ae"
SRCBRANCH = "3.10+fio"
