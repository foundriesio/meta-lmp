PROVIDES_freedom-u540 = "virtual/bootloader"
