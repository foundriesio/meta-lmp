FILESEXTRAPATHS:prepend := "${THISDIR}/files:"

SRC_URI:append:lmp = " file://lmp.cfg"
