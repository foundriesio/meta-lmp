EXTRA_OECONF += "--with-nss-modules='files altfiles'"
