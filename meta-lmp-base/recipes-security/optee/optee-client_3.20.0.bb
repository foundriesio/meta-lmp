require optee-client-fio.inc

SRCREV = "dd2d39b49975d2ada7870fe2b7f5a84d0d3860dc"

SRC_URI += " \
	file://0001-FIO-extras-pkcs11-change-UUID-to-avoid-conflict-with.patch \
"
