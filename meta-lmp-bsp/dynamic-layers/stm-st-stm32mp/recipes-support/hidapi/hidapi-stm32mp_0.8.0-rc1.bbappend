FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

SRC_URI += "file://0001-configure.ac-remove-duplicate-AC_CONFIG_MACRO_DIR-22.patch"
