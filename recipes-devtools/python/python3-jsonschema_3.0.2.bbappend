RDEPENDS_${PN} += "python3-attrs python3-pyrsistent"
