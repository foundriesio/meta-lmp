FILESEXTRAPATHS:prepend := "${THISDIR}/tegra-helper-scripts:"
