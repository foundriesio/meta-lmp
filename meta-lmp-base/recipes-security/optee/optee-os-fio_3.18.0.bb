require optee-os-fio.inc

PV = "3.18.0+git"
SRCREV = "939fb9c74117873193143f3eb3e76b385ba87cc0"
SRCBRANCH = "3.18+fio"
