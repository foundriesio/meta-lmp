# This recipe uses older toolchain and '-fmacro-prefix-map' is not supported
DEBUG_PREFIX_MAP = ""
