IMA_POLICY = "ima_policy_simple"
