do_install:append() {
    # data files provided by dependencies
    rm -rf ${D}/usr/share/lshw
}
