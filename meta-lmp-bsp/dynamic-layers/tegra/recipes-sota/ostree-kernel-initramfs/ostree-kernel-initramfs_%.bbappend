INITRAMFS_FSTYPES:remove:tegra = "cpio.gz.cboot cpio.gz.cboot.bup-payload"
