require recipes-security/optee/optee-os-fio.inc

SRCREV = "a27f70eb44fdd45d713c67d14139b88fc2dccf0c"
SRCBRANCH = "3.21+fio-imx"

DEFAULT_PREFERENCE = "-1"
