INHIBIT_PACKAGE_STRIP = "0"
