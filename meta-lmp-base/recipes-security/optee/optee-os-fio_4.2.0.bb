require optee-os-fio.inc

SRCREV = "1cd564f415281f0ea33c7a4eeb03347f0a535a26"
SRCBRANCH = "4.2.0+fio"
