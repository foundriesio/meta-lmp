require optee-os-fio.inc

SRCREV = "9048d3d2873b7d7d9f2b5594ce55c342b4cb6049"
SRCBRANCH = "3.21+fio"
