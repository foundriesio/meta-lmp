require optee-client-fio.inc

SRCREV = "3eac340a781c00ccd61b151b0e9c22a8c6e9f9f0"

SRC_URI += " \
	file://0001-FIO-extras-pkcs11-change-UUID-to-avoid-conflict-with.patch \
"
