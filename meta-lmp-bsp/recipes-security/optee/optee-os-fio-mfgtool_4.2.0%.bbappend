require optee-os-fio-bsp-mfgtool.inc
require optee-os-fio-bsp-common.inc
