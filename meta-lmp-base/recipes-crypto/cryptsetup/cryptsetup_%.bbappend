FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"

SRC_URI += "file://0001-reencrypt-online-reencryption-with-TPM-PKCS11-tokens.patch"
