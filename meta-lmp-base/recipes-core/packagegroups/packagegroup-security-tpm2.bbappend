# Trousers is relevant with TPM 1.2 (not supported by LmP)
RDEPENDS:packagegroup-security-tpm2:remove = "trousers"
