require optee-client-fio.inc

SRCREV = "9a337049c52495e5e16b4a94decaa3e58fce793e"

SRC_URI += " \
	file://0001-FIO-extras-pkcs11-change-UUID-to-avoid-conflict-with.patch \
"
