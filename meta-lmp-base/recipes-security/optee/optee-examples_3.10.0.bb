require optee-examples.inc

SRCREV = "c6eb00a9d83bf068a37e4806c97f582bb16e2973"
