# Disable by default on corstone700 until it is functional
SYSTEMD_AUTO_ENABLE:${PN}:corstone700 = "disable"
