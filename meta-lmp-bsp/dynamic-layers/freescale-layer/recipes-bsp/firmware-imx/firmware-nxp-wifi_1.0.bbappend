RPROVIDES:${PN}-nxp-common = "linux-firmware-nxp-common"
RREPLACES:${PN}-nxp-common = "linux-firmware-nxp-common"
RCONFLICTS:${PN}-nxp-common = "linux-firmware-nxp-common"
