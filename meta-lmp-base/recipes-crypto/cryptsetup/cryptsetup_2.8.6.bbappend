DEFAULT_PREFERENCE = "-1"
