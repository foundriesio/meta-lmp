FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"

HCI_ATTACH_BOARD:imx8mm-lpddr4-evk = "fsl,imx8mm-evkb"
HCI_ATTACH_BOARD:imx8mp-lpddr4-evk = "fsl,imx8mp-evk"
