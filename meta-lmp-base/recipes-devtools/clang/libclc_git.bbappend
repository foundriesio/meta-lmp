lmp-clang.inc