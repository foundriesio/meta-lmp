RDEPENDS:${PN} = "optee-os-ta optee-client"
