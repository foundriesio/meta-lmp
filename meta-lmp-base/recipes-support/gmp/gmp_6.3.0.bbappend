# Upstream is dual licensed on GPLv2 | LGPLv3, so force GPLv2 in order
# to allow safe checks via image-license-checker
LICENSE = "GPL-2.0-or-later"
