FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:${THISDIR}/u-boot-fio:"
