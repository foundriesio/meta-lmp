RDEPENDS:${PN}:append = " tegra-libraries-cuda"
