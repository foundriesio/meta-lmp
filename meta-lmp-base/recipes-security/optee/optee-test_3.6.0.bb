require optee-test.inc

SRCREV = "40aacb6dc33bbf6ee329f40274bfe7bb438bbf53"

SRC_URI += " \
    file://use-python3-instead-of-python.patch \
"
