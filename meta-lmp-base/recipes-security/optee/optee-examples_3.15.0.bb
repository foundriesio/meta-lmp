require optee-examples.inc

SRCREV = "ff4b493e267d40bcf508acc300da296a3a2adac2"

DEFAULT_PREFERENCE = "-1"
