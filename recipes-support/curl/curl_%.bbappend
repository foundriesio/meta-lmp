EXTRA_OECONF_append_sota = " \
    --with-ca-path=${sysconfdir}/ssl/certs \
"
