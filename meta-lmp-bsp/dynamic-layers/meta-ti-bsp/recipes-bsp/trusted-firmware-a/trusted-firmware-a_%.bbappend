# From the 08.04.00.005 dunfell tag
BRANCH:k3 = "master"
SRC_URI:k3 = "git://git.trustedfirmware.org/TF-A/trusted-firmware-a.git;protocol=https;name=tfa;branch=${BRANCH}"
SRCREV_tfa:k3 = "453abc80b2eacbf2816c838e47e40f063227d934"
